Commit message: add backflip

File: robots/simple_humanoid/urdf/simple_humanoid.urdf (robot description, URDF)
Before this commit: robot simple_humanoid, 32 links, 31 joints
Links:
- link BODY: geometry collision cylinder length=1 radius=1; collision mesh filename=../meshes/box.stl
